options:
  parameters:
    author: sdr
    generate_options: qt_gui
    id: fm_demod
    output_language: python
    title: FM Demodulation
  states: {}

blocks:
- name: deviation
  id: variable_qtgui_range
  parameters:
    label: Frequency Deviation
    start: '0'
    step: '10000'
    stop: '1000000'
    value: '25000'
  states: {}
- name: fm_station
  id: variable_qtgui_range
  parameters:
    label: FM Station
    start: '88100000'
    step: '200000'
    stop: '107500000'
    value: '99500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2304000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (2*math.pi*deviation)/(samp_rate/6)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '131072'
    filter_source: '''Auto'''
    frequency: fm_station
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: round(samp_rate)
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '6'
    gain: '1'
    samp_rate: round(samp_rate)
    type: fir_filter_ccf
    width: '48000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '8'
    gain: '1'
    samp_rate: samp_rate/6
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/6
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@1
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@2
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Input Spectrum
    label1: LPF Spectrum
    label2: Demod Spectrum
    label3: Demod Signal
    num_tabs: '4'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: qtgui_tab_widget_0@3
    size: '1024'
    srate: '48000'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
