options:
  parameters:
    generate_options: hb
    id: iio_input_chanel_attribute
    output_language: python
    title: IIO Input Channel Attribute
  states: {}

blocks:
- name: attribute
  id: parameter
  parameters:
    label: Attribute
    type: str
    value: ''
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.to_pmt({attribute: value})'
    period: '10000'
  states: {state: disabled}
- name: blocks_var_to_msg_1
  id: blocks_var_to_msg
  parameters:
    msgname: attribute
    target: value
  states: {state: disabled}
- name: channel_name
  id: parameter
  parameters:
    label: Channel Name
    type: str
    value: ''
  states: {}
- name: device_name
  id: parameter
  parameters:
    label: Device Name/ID
    type: str
    value: ''
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are sync_block, decim_block, interp_block
          """Embedded Python Block to Convert Message Pair to Meta Value"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Message Pair to Meta Value',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.in_port = pmt.intern("inpair")
              self.out_port = pmt.intern("outmeta");
              self.message_port_register_in(self.in_port)
              self.message_port_register_out(self.out_port)
              self.set_msg_handler(self.in_port, self.handle_msg)

          def handle_msg(self, in_msg):
              key = pmt.car(in_msg)
              val = pmt.cdr(in_msg)
              out_msg = pmt.make_dict()
              out_msg = pmt.dict_add(out_msg, key, val) 
              self.message_port_pub(self.out_port, out_msg)
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):  # other base classes are sync_block, decim_block, interp_block
          """Embedded Python Block to Create IIO Attribute Message"""

          def __init__(self, attribute : str = "", value : str = ""):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='IIO Attribute Message',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.attribute = attribute
              self._value = value
              
              # Create message port
              self.out_port = pmt.intern("out");
              self.message_port_register_out(self.out_port)
              
          def start(self):
              # Send message at time=0
              self.send_msg()
              
          def get_value(self):
              return self._value
              
          def set_value(self, value):
              self._value = value
              # Send message on updates to value
              self.send_msg()
              
          def del_value(self): 
               del self._value
               
          def send_msg(self):
              msg = pmt.to_pmt({self.attribute : self.value})
              self.message_port_pub(self.out_port, msg)
              
          # Setup callback functions for value
          value = property(get_value, set_value, del_value)
    attribute: attribute
    value: value
  states: {}
- name: iio_attr_sink_0_0_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: channel_name
    device: device_name
    output: 'False'
    uri: uri
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context URI
    type: str
    value: ''
  states: {}
- name: value
  id: parameter
  parameters:
    label: Value
    type: str
    value: ''
  states: {}

connections:
- [blocks_message_strobe_0, strobe, iio_attr_sink_0_0_0_0_0, attr]
- [blocks_var_to_msg_1, msgout, blocks_message_strobe_0, set_msg]
- [blocks_var_to_msg_1, msgout, epy_block_0, inpair]
- [epy_block_0, outmeta, iio_attr_sink_0_0_0_0_0, attr]
- [epy_block_1, out, iio_attr_sink_0_0_0_0_0, attr]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
