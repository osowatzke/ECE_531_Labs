options:
  parameters:
    generate_options: hb
    id: pluto_iio_device_sink
    output_language: python
    title: Pluto IIO Device Sink
  states: {}

blocks:
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15-1
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15-1
  states: {}
- name: buffer_size
  id: parameter
  parameters:
    label: Buffer size
    type: intx
    value: '32768'
  states: {}
- name: cyclic
  id: parameter
  parameters:
    label: Cyclic
    type: str
    value: '"True"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):  # other base classes are sync_block, decim_block, interp_block
          """Embedded Python Block to Create IIO Attribute Message"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='IIO Attribute Message',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              
              # Create message port
              # self.out_port = pmt.intern("out");
              # self.message_port_register_out(self.out_port)
              self.taps = [-15,-27,-23,-6,17,33,31,9,-23,-47,-45,-13,34,69,67,21,-49,-102,-99,-32,69,146,143,48,-96,-204,-200,-69,129,278,275,97,-170,\
      	        -372,-371,-135,222,494,497,187,-288,-654,-665,-258,376,875,902,363,-500,-1201,-1265,-530,699,1748,1906,845,-1089,-2922,-3424,\
      	        -1697,2326,7714,12821,15921,15921,12821,7714,2326,-1697,-3424,-2922,-1089,845,1906,1748,699,-530,-1265,-1201,-500,363,902,875,\
      	        376,-258,-665,-654,-288,187,497,494,222,-135,-371,-372,-170,97,275,278,129,-69,-200,-204,-96,48,143,146,69,-32,-99,-102,-49,21,\
      	        67,69,34,-13,-45,-47,-23,9,31,33,17,-6,-23,-27,-15]
              
          def start(self):
              # Send message at time=0
              self.send_msg()
               
          def send_msg(self):
              msg_value = "RX 3 GAIN -6 DEC 4\n"
              msg_value += "TX 3 GAIN 0 INT 4\n"
              for i in range(len(self.taps)):
                  msg_value += str(self.taps) + "," + str(self.taps) + "\n"
              print(msg_value)
              #msg = pmt.to_pmt({'filter_fir_config' : msg_value})
              #self.message_port_pub(self.out_port, msg)
  states: {state: disabled}
- name: iio_attr_sink_1
  id: iio_attr_sink
  parameters:
    attr_type: '1'
    device: ad9361-phy
    uri: uri
  states: {state: disabled}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: filter_fir_config
    interval: '0'
    value: '"'
  states: {state: disabled}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '32768'
    channels: '["voltage0","voltage1"]'
    cyclic: eval(cyclic)
    device: '"cf-ad9361-dds-core-lpc"'
    device_phy: '"ad9361-phy"'
    interpolation: '1'
    params: '[]'
    uri: uri
  states: {}
- name: iio_output_chanel_attribute_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"frequency"'
    channel_name: '"altvoltage1"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(lo_freq)
  states: {}
- name: iio_output_chanel_attribute_0_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"hardwaregain"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(-tx_atten)
  states: {}
- name: iio_output_chanel_attribute_0_0_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"sampling_frequency"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(sample_rate)
  states: {}
- name: iio_output_chanel_attribute_0_0_1
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"rf_bandwidth"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(rf_bandwidth)
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    label: LO Frequency
    type: intx
    value: '2400000000'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rf_bandwidth
  id: parameter
  parameters:
    label: RF Bandwidth (Hz)
    type: intx
    value: '20000000'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.084e6
  states: {}
- name: tx_atten
  id: parameter
  parameters:
    label: Attenuation TX1 (dB)
    type: intx
    value: '10'
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context URI
    type: str
    value: ''
  states: {}

connections:
- [blocks_complex_to_float_1, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_float_1, '1', blocks_float_to_short_0_0, '0']
- [blocks_float_to_short_0, '0', iio_device_sink_0, '0']
- [blocks_float_to_short_0_0, '0', iio_device_sink_0, '1']
- [pad_source_0, '0', blocks_complex_to_float_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
