options:
  parameters:
    generate_options: hb
    id: pluto_iio_device_sink
    output_language: python
    title: Pluto IIO Device Sink
  states: {}

blocks:
- name: auto_filter
  id: parameter
  parameters:
    label: Auto Filter
    type: str
    value: '"True"'
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15-1
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15-1
  states: {}
- name: buffer_size
  id: parameter
  parameters:
    label: Buffer size
    type: intx
    value: '32768'
  states: {}
- name: cyclic
  id: parameter
  parameters:
    label: Cyclic
    type: str
    value: '"True"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.basic_block):  # other base classes are sync_block, decim_block, interp_block
          """Embedded Python Block to Create IIO Filter Messages"""

          def __init__(self, sample_rate : int = 2084000, auto_filter : bool = True, filter_path : str = ""):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='FIR Config Message',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              
              # Set Default Properties
              self._sample_rate = sample_rate
              self.auto_filter = auto_filter
              if self.auto_filter:
                  self.filter_path = self.auto_filter_path()
              else:
                  self.filter_path = filter_path
              
              # Create message port to enable filter
              self.en_port = pmt.intern("en_out")        
              self.message_port_register_out(self.en_port)
              
              # Create message port to write filter coefficients
              self.coefs_port = pmt.intern("coefs_out")
              self.message_port_register_out(self.coefs_port)
                      
          def start(self):
              # Send message at time=0
              self.send_msg()
               
          def send_msg(self):
              # Disable filter if no filter is provided
              if self.filter_path == "":
                  # msg = pmt.to_pmt({'filter_fir_config' : "RX 3 GAIN 0 DEC 4\nTX 3 GAIN 0 INT 4\n\n"})
                  # self.message_port_pub(self.coefs_port, msg)
                  msg = pmt.to_pmt({'filter_fir_en' : '0'})
                  self.message_port_pub(self.en_port, msg)
              else:
                  # Enable filter if file exists
                  try:
                      with open(self.filter_path, 'r') as file:
                          msg = pmt.to_pmt({'filter_fir_config' : file.read()})
                      self.message_port_pub(self.coefs_port, msg)
                      # Wait for coefficients to be loaded
                      time.sleep(1.0)
                      msg = pmt.to_pmt({'filter_fir_en' : '1'})
                      self.message_port_pub(self.en_port, msg)
                  # Otherwise, disable filter
                  except:
                      print("Unable to find file: \"%s\"" % self.filter_path)
                      msg = pmt.to_pmt({'filter_fir_en','0'})
                      self.message_port_pub(self.en_port, msg)
              
          # Function updates filter coefficients when they change
          def update_filter_path(self, filter_path):
              if (self.filter_path != filter_path):
                  self.filter_path = filter_path
                  self.send_msg()
             
          # Automatically select filter coefficients based on sample rate
          def auto_filter_path(self):
              if (self._sample_rate <= 20000000):
                  filter_path = "fir_128_4.txt"
              elif (self._sample_rate <= 40000000):
                  filter_path = "fir_128_2.txt"
              elif (self._sample_rate <= 53333333):
                  filter_path = "fir_96_2.txt"
              else:
                  filter_path = "fir_64_2.txt"
              return filter_path
              
          # Function updates filter with automatically computed coefficients
          def auto_update_filter_path(self):
              filter_path = self.auto_filter_path()
              self.update_filter_path(filter_path)
              
          def get_sample_rate(self):
              return self._sample_rate
              
          def set_sample_rate(self, sample_rate):
              self.sample_rate = sample_rate
              if self.auto_filter:
                  self.auto_update_filter_path() 
              
          def del_sample_rate(self):
              del self._sample_rate
              
          # Setup callback functions for sample rate
          sample_rate = property(get_sample_rate, set_sample_rate, del_sample_rate)
    auto_filter: eval(auto_filter)
    filter_path: filter_path
    sample_rate: sample_rate
  states: {}
- name: filter_path
  id: parameter
  parameters:
    label: Filter
    type: str
    value: '""'
  states: {}
- name: iio_attr_sink_1
  id: iio_attr_sink
  parameters:
    attr_type: '1'
    device: ad9361-phy
    uri: uri
  states: {}
- name: iio_attr_sink_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"filter_fir_en"'
    device: ad9361-phy
    output: 'False'
    uri: uri
  states: {state: disabled}
- name: iio_attr_sink_1_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: ad9361-phy
    output: 'True'
    uri: uri
  states: {}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: filter_fir_config
    interval: '0'
    value: '"'
  states: {state: disabled}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '32768'
    channels: '["voltage0","voltage1"]'
    cyclic: eval(cyclic)
    device: '"cf-ad9361-dds-core-lpc"'
    device_phy: '"ad9361-phy"'
    interpolation: '1'
    params: '[]'
    uri: uri
  states: {}
- name: iio_output_chanel_attribute_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"frequency"'
    channel_name: '"altvoltage1"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(lo_freq)
  states: {}
- name: iio_output_chanel_attribute_0_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"hardwaregain"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(-tx_atten)
  states: {}
- name: iio_output_chanel_attribute_0_0_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"sampling_frequency"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(sample_rate)
  states: {}
- name: iio_output_chanel_attribute_0_0_1
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"rf_bandwidth"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(rf_bandwidth)
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    label: LO Frequency
    type: intx
    value: '2400000000'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rf_bandwidth
  id: parameter
  parameters:
    label: RF Bandwidth (Hz)
    type: intx
    value: '20000000'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.084e6
  states: {}
- name: tx_atten
  id: parameter
  parameters:
    label: Attenuation TX1 (dB)
    type: intx
    value: '10'
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context URI
    type: str
    value: ''
  states: {}

connections:
- [blocks_complex_to_float_1, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_float_1, '1', blocks_float_to_short_0_0, '0']
- [blocks_float_to_short_0, '0', iio_device_sink_0, '0']
- [blocks_float_to_short_0_0, '0', iio_device_sink_0, '1']
- [epy_block_1, coefs_out, iio_attr_sink_1, attr]
- [epy_block_1, en_out, iio_attr_sink_1_1, attr]
- [pad_source_0, '0', blocks_complex_to_float_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
