options:
  parameters:
    generate_options: hb
    id: pluto_iio_device_sink
    output_language: python
    title: Pluto IIO Device Sink
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage0
    device: ad9361-phy
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: ad9361-phy
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: ad9361-phy
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    output: 'False'
    samples_per_update: '1024'
    type: '0'
    update_interval_ms: '1'
    uri: 'local:'
  states: {}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: frequency
    interval: '0'
    value: str(lo_freq)
  states: {}
- name: iio_attr_updater_0_0
  id: iio_attr_updater
  parameters:
    attr: sampling_frequency
    interval: '0'
    value: str(samp_freq)
  states: {}
- name: iio_attr_updater_0_0_0
  id: iio_attr_updater
  parameters:
    attr: rf_bandwidth
    interval: '0'
    value: str(rf_bandwidth)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    label: LO Frequency
    type: eng_float
    value: '2400000000'
  states: {}
- name: rf_bandwidth
  id: parameter
  parameters:
    label: RF Bandwidth (Hz)
    type: eng_float
    value: 20e6
  states: {}
- name: samp_freq
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.084e6
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context uri
    type: str
    value: ''
  states: {}

connections:
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_0_0_0, out, iio_attr_sink_0_0_0, attr]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
