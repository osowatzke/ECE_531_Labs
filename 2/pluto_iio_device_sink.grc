options:
  parameters:
    generate_options: hb
    id: pluto_iio_device_sink
    output_language: python
    title: Pluto IIO Device Sink
  states: {}

blocks:
- name: auto_filter
  id: parameter
  parameters:
    label: Auto Filter
    type: str
    value: '"True"'
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15-1
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15-1
  states: {}
- name: buffer_size
  id: parameter
  parameters:
    label: Buffer size
    type: intx
    value: '32768'
  states: {}
- name: cyclic
  id: parameter
  parameters:
    label: Cyclic
    type: str
    value: '"True"'
  states: {}
- name: filter_path
  id: parameter
  parameters:
    label: Filter
    type: str
    value: '""'
  states: {}
- name: iio_attr_sink_1
  id: iio_attr_sink
  parameters:
    attr_type: '1'
    device: ad9361-phy
    uri: uri
  states: {}
- name: iio_attr_sink_1_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: ad9361-phy
    output: 'True'
    uri: uri
  states: {}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '32768'
    channels: '["voltage0","voltage1"]'
    cyclic: eval(cyclic)
    device: '"cf-ad9361-dds-core-lpc"'
    device_phy: '"ad9361-phy"'
    interpolation: '1'
    params: '[]'
    uri: uri
  states: {}
- name: iio_fir_config_0
  id: iio_fir_config
  parameters:
    auto_filter: auto_filter
    filter_path: filter_path
    sample_rate: sample_rate
  states: {}
- name: iio_output_chanel_attribute_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"frequency"'
    channel_name: '"altvoltage1"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(lo_freq)
  states: {}
- name: iio_output_chanel_attribute_0_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"hardwaregain"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(-tx_atten)
  states: {}
- name: iio_output_chanel_attribute_0_0_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"sampling_frequency"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(sample_rate)
  states: {}
- name: iio_output_chanel_attribute_0_0_1
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"rf_bandwidth"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(rf_bandwidth)
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    label: LO Frequency
    type: intx
    value: '2400000000'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rf_bandwidth
  id: parameter
  parameters:
    label: RF Bandwidth (Hz)
    type: intx
    value: '20000000'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.084e6
  states: {}
- name: tx_atten
  id: parameter
  parameters:
    label: Attenuation TX1 (dB)
    type: intx
    value: '10'
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context URI
    type: str
    value: ''
  states: {}

connections:
- [blocks_complex_to_float_1, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_float_1, '1', blocks_float_to_short_0_0, '0']
- [blocks_float_to_short_0, '0', iio_device_sink_0, '0']
- [blocks_float_to_short_0_0, '0', iio_device_sink_0, '1']
- [iio_fir_config_0, coefs_out, iio_attr_sink_1, attr]
- [iio_fir_config_0, en_out, iio_attr_sink_1_1, attr]
- [pad_source_0, '0', blocks_complex_to_float_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
