options:
  parameters:
    generate_options: hb
    id: iio_output_chanel_attribute
    output_language: python
    title: IIO Output Channel Attribute
  states: {}

blocks:
- name: attribute
  id: parameter
  parameters:
    label: Attribute
    type: str
    value: ''
  states: {}
- name: channel_name
  id: parameter
  parameters:
    label: Channel Name
    type: str
    value: ''
  states: {}
- name: device_name
  id: parameter
  parameters:
    label: Device Name/ID
    type: str
    value: ''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):  # other base classes are sync_block, decim_block, interp_block
          """Embedded Python Block to Create IIO Attribute Message"""

          def __init__(self, attribute : str = "", value : str = ""):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='IIO Attribute Message',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.attribute = attribute
              self._value = value
              
              # Create message port
              self.out_port = pmt.intern("out");
              self.message_port_register_out(self.out_port)
              
          def start(self):
              # Send message at time=0
              self.send_msg()
              
          def get_value(self):
              return self._value
              
          def set_value(self, value):
              self._value = value
              # Send message on updates to value
              self.send_msg()
              
          def del_value(self): 
               del self._value
               
          def send_msg(self):
              msg = pmt.to_pmt({self.attribute : self.value})
              self.message_port_pub(self.out_port, msg)
              
          # Setup callback functions for value
          value = property(get_value, set_value, del_value)
    attribute: attribute
    value: value
  states: {}
- name: iio_attr_sink_0_0_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: channel_name
    device: device_name
    output: 'True'
    uri: uri
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context URI
    type: str
    value: ''
  states: {}
- name: value
  id: parameter
  parameters:
    label: Value
    type: str
    value: ''
  states: {}

connections:
- [epy_block_1, out, iio_attr_sink_0_0_0_0_0, attr]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
