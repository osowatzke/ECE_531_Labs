options:
  parameters:
    generate_options: hb
    id: pluto_iio_device_source
    output_language: python
    title: Pluto IIO Device Source
  states: {}

blocks:
- name: auto_filter
  id: parameter
  parameters:
    label: Auto Filter
    type: str
    value: '"True"'
  states: {}
- name: bb_dc_correction
  id: parameter
  parameters:
    label: BB DC Correction
    type: str
    value: 'True'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**11-1
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**11-1
  states: {}
- name: buffer_size
  id: parameter
  parameters:
    label: Buffer Size
    type: intx
    value: '32768'
  states: {}
- name: filter_path
  id: parameter
  parameters:
    label: Filter
    type: str
    value: '""'
  states: {}
- name: gain_control_mode
  id: parameter
  parameters:
    label: Gain Mode (RX1)
    type: str
    value: manual
  states: {}
- name: iio_attr_sink_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '1'
    device: ad9361-phy
    uri: uri
  states: {}
- name: iio_attr_sink_1_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: ad9361-phy
    output: 'False'
    uri: uri
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: buffer_size
    channels: '["voltage0","voltage1"]'
    decimation: '1'
    device: '"cf-ad9361-lpc"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: uri
  states: {}
- name: iio_fir_config_0
  id: iio_fir_config
  parameters:
    auto_filter: auto_filter
    filter_path: filter_path
    sample_rate: sample_rate
  states: {}
- name: iio_input_chanel_attribute_1_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"rf_dc_offset_tracking_en"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: '''1'' if rf_dc_correction else ''0'''
  states: {}
- name: iio_input_chanel_attribute_1_0_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"sampling_frequency"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(sample_rate)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"bb_dc_offset_tracking_en"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: '''1'' if bb_dc_correction else ''0'''
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"gain_control_mode"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(gain_control_mode)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"hardwaregain"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(manual_gain)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1_0_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"rf_bandwidth"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(rf_bandwidth)
  states: {}
- name: iio_output_chanel_attribute_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"frequency"'
    channel_name: '"altvoltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(lo_freq)
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    label: LO Frequency
    type: intx
    value: '2400000000'
  states: {}
- name: manual_gain
  id: parameter
  parameters:
    label: Manual Gain (RX1)(dB)
    type: intx
    value: '64'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: rf_bandwidth
  id: parameter
  parameters:
    label: RF Bandwidth (Hz)
    type: intx
    value: '20000000'
  states: {}
- name: rf_dc_correction
  id: parameter
  parameters:
    label: RF DC Correction
    type: str
    value: 'True'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.084e6
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context URI
    type: str
    value: ''
  states: {}

connections:
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']
- [iio_fir_config_0, coefs_out, iio_attr_sink_1_0, attr]
- [iio_fir_config_0, en_out, iio_attr_sink_1_1_0, attr]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
