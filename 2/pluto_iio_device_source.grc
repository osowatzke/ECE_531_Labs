options:
  parameters:
    generate_options: hb
    id: pluto_iio_device_source
    output_language: python
    title: Pluto IIO Device Source
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: bb_dc_correction
  id: parameter
  parameters:
    label: BB DC Correction
    type: intx
    value: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**11-1
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**11-1
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: hardwaregain
    target: str(manual_gain)
  states: {state: disabled}
- name: buffer_size
  id: parameter
  parameters:
    label: Buffer Size
    type: intx
    value: '32768'
  states: {}
- name: gain_control_mode
  id: parameter
  parameters:
    label: Gain Mode (RX1)
    type: str
    value: manual
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"altvoltage0"'
    device: '"ad9361-phy"'
    output: 'True'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0_0_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0_0_0_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    output: 'False'
    samples_per_update: '1024'
    type: '0'
    update_interval_ms: '1'
    uri: 'local:'
  states: {state: disabled}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: '"frequency"'
    interval: '0'
    value: str(lo_freq)
  states: {}
- name: iio_attr_updater_0_0
  id: iio_attr_updater
  parameters:
    attr: '"sampling_frequency"'
    interval: '0'
    value: str(samp_freq)
  states: {}
- name: iio_attr_updater_0_0_0
  id: iio_attr_updater
  parameters:
    attr: '"rf_bandwidth"'
    interval: '0'
    value: str(rf_bandwidth)
  states: {}
- name: iio_attr_updater_0_0_0_0
  id: iio_attr_updater
  parameters:
    attr: '"gain_control_mode"'
    interval: '0'
    value: gain_control_mode
  states: {}
- name: iio_attr_updater_0_0_0_0_0
  id: iio_attr_updater
  parameters:
    attr: '"hardwaregain"'
    interval: '0'
    value: str(manual_gain)
  states: {}
- name: iio_attr_updater_0_0_0_0_1
  id: iio_attr_updater
  parameters:
    attr: '"bb_dc_offset_tracking_en"'
    interval: '0'
    value: str(bb_dc_correction)
  states: {}
- name: iio_attr_updater_0_0_0_0_1_0
  id: iio_attr_updater
  parameters:
    attr: '"rf_dc_offset_tracking_en"'
    interval: '0'
    value: str(rf_dc_correction)
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: buffer_size
    channels: '["voltage0","voltage1"]'
    decimation: '1'
    device: '"cf-ad9361-lpc"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: uri
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: lo_freq
  id: parameter
  parameters:
    label: LO Frequency
    type: eng_float
    value: '2400000000'
  states: {}
- name: manual_gain
  id: parameter
  parameters:
    label: Manual Gain (RX1)(dB)
    type: eng_float
    value: '64'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: parameter_0
  id: parameter
  parameters:
    value: '0'
  states: {state: disabled}
- name: rf_bandwidth
  id: parameter
  parameters:
    label: RF Bandwidth (Hz)
    type: intx
    value: '20000000'
  states: {}
- name: rf_dc_correction
  id: parameter
  parameters:
    label: RF DC Correction
    type: intx
    value: '1'
  states: {}
- name: samp_freq
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.084e6
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context uri
    type: str
    value: ''
  states: {}

connections:
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_0_0_0, out, iio_attr_sink_0_0_0, attr]
- [iio_attr_updater_0_0_0_0, out, iio_attr_sink_0_0_0_0, attr]
- [iio_attr_updater_0_0_0_0_0, out, iio_attr_sink_0_0_0_0_0, attr]
- [iio_attr_updater_0_0_0_0_1, out, iio_attr_sink_0_0_0_0_1, attr]
- [iio_attr_updater_0_0_0_0_1_0, out, iio_attr_sink_0_0_0_0_1_0, attr]
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
