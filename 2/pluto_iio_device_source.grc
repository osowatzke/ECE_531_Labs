options:
  parameters:
    generate_options: hb
    id: pluto_iio_device_source
    output_language: python
    title: Pluto IIO Device Source
  states: {}

blocks:
- name: auto_filter
  id: parameter
  parameters:
    label: Auto Filter
    type: str
    value: '"True"'
  states: {}
- name: bb_dc_correction
  id: parameter
  parameters:
    label: BB DC Correction
    type: intx
    value: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**11-1
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**11-1
  states: {}
- name: buffer_size
  id: parameter
  parameters:
    label: Buffer Size
    type: intx
    value: '32768'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.basic_block):  # other base classes are sync_block, decim_block, interp_block
          """Embedded Python Block to Create IIO Filter Messages"""

          def __init__(self, sample_rate : int = 2084000, auto_filter : bool = True, filter_path : str = ""):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='FIR Config Message',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              
              # Set Default Properties
              self._sample_rate = sample_rate
              self.auto_filter = auto_filter
              if self.auto_filter:
                  self.filter_path = self.auto_filter_path()
              else:
                  self.filter_path = filter_path
              
              # Create message port to enable filter
              self.en_port = pmt.intern("en_out")        
              self.message_port_register_out(self.en_port)
              
              # Create message port to write filter coefficients
              self.coefs_port = pmt.intern("coefs_out")
              self.message_port_register_out(self.coefs_port)
                      
          def start(self):
              # Send message at time=0
              self.send_msg()
               
          def send_msg(self):
              # Disable filter if no filter is provided
              if self.filter_path == "":
                  # msg = pmt.to_pmt({'filter_fir_config' : "RX 3 GAIN 0 DEC 4\nTX 3 GAIN 0 INT 4\n\n"})
                  # self.message_port_pub(self.coefs_port, msg)
                  msg = pmt.to_pmt({'filter_fir_en' : '0'})
                  self.message_port_pub(self.en_port, msg)
              else:
                  # Enable filter if file exists
                  try:
                      with open(self.filter_path, 'r') as file:
                          msg = pmt.to_pmt({'filter_fir_config' : file.read()})
                      self.message_port_pub(self.coefs_port, msg)
                      # Wait for coefficients to be loaded
                      time.sleep(1.0)
                      msg = pmt.to_pmt({'filter_fir_en' : '1'})
                      self.message_port_pub(self.en_port, msg)
                  # Otherwise, disable filter
                  except:
                      print("Unable to find file: \"%s\"" % self.filter_path)
                      msg = pmt.to_pmt({'filter_fir_en','0'})
                      self.message_port_pub(self.en_port, msg)
              
          # Function updates filter coefficients when they change
          def update_filter_path(self, filter_path):
              if (self.filter_path != filter_path):
                  self.filter_path = filter_path
                  self.send_msg()
             
          # Automatically select filter coefficients based on sample rate
          def auto_filter_path(self):
              if (self._sample_rate <= 20000000):
                  filter_path = "fir_128_4.txt"
              elif (self._sample_rate <= 40000000):
                  filter_path = "fir_128_2.txt"
              elif (self._sample_rate <= 53333333):
                  filter_path = "fir_96_2.txt"
              else:
                  filter_path = "fir_64_2.txt"
              return filter_path
              
          # Function updates filter with automatically computed coefficients
          def auto_update_filter_path(self):
              filter_path = self.auto_filter_path()
              self.update_filter_path(filter_path)
              
          def get_sample_rate(self):
              return self._sample_rate
              
          def set_sample_rate(self, sample_rate):
              self.sample_rate = sample_rate
              if self.auto_filter:
                  self.auto_update_filter_path() 
              
          def del_sample_rate(self):
              del self._sample_rate
              
          # Setup callback functions for sample rate
          sample_rate = property(get_sample_rate, set_sample_rate, del_sample_rate)
    auto_filter: eval(auto_filter)
    filter_path: filter_path
    sample_rate: sample_rate
  states: {}
- name: filter_path
  id: parameter
  parameters:
    label: Filter
    type: str
    value: '""'
  states: {}
- name: gain_control_mode
  id: parameter
  parameters:
    label: Gain Mode (RX1)
    type: str
    value: manual
  states: {}
- name: iio_attr_sink_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '1'
    device: ad9361-phy
    uri: uri
  states: {}
- name: iio_attr_sink_1_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: ad9361-phy
    output: 'False'
    uri: uri
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: buffer_size
    channels: '["voltage0","voltage1"]'
    decimation: '1'
    device: '"cf-ad9361-lpc"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: uri
  states: {}
- name: iio_input_chanel_attribute_1_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"rf_dc_offset_tracking_en"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(rf_dc_correction)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"sampling_frequency"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(sample_rate)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"bb_dc_offset_tracking_en"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(bb_dc_correction)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"gain_control_mode"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(gain_control_mode)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"hardwaregain"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(manual_gain)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1_0_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"rf_bandwidth"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(rf_bandwidth)
  states: {}
- name: iio_output_chanel_attribute_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"frequency"'
    channel_name: '"altvoltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(lo_freq)
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    label: LO Frequency
    type: intx
    value: '2400000000'
  states: {}
- name: manual_gain
  id: parameter
  parameters:
    label: Manual Gain (RX1)(dB)
    type: intx
    value: '64'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: rf_bandwidth
  id: parameter
  parameters:
    label: RF Bandwidth (Hz)
    type: intx
    value: '20000000'
  states: {}
- name: rf_dc_correction
  id: parameter
  parameters:
    label: RF DC Correction
    type: intx
    value: '1'
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.084e6
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context URI
    type: str
    value: ''
  states: {}

connections:
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [epy_block_1_0, coefs_out, iio_attr_sink_1_0, attr]
- [epy_block_1_0, en_out, iio_attr_sink_1_1_0, attr]
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
