options:
  parameters:
    generate_options: hb
    id: pluto_iio_device_source
    output_language: python
    title: Pluto IIO Device Source
  states: {}

blocks:
- name: bb_dc_correction
  id: parameter
  parameters:
    label: BB DC Correction
    type: intx
    value: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**11-1
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**11-1
  states: {}
- name: blocks_var_to_msg_1
  id: blocks_var_to_msg
  parameters:
    msgname: '"hardwaregain"'
    target: str(manual_gain)
  states: {state: disabled}
- name: buffer_size
  id: parameter
  parameters:
    label: Buffer Size
    type: intx
    value: '32768'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are sync_block, decim_block, interp_block
          """Embedded Python Block to Convert Message Pair to Meta Value"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Message Pair to Meta Value',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.in_port = pmt.intern("inpair")
              self.out_port = pmt.intern("outmeta");
              self.message_port_register_in(self.in_port)
              self.message_port_register_out(self.out_port)
              self.set_msg_handler(self.in_port, self.handle_msg)

          def handle_msg(self, in_msg):
              key = pmt.car(in_msg)
              val = pmt.cdr(in_msg)
              out_msg = pmt.make_dict()
              out_msg = pmt.dict_add(out_msg, key, val) 
              self.message_port_pub(self.out_port, out_msg)
  states: {state: disabled}
- name: gain_control_mode
  id: parameter
  parameters:
    label: Gain Mode (RX1)
    type: str
    value: manual
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: buffer_size
    channels: '["voltage0","voltage1"]'
    decimation: '1'
    device: '"cf-ad9361-lpc"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: uri
  states: {}
- name: iio_input_chanel_attribute_1_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"rf_dc_offset_tracking_en"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(rf_dc_correction)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"sampling_frequency"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(sampling_frequency)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"bb_dc_offset_tracking_en"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(bb_dc_correction)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"gain_control_mode"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(gain_control_mode)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"hardwaregain"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(manual_gain)
  states: {}
- name: iio_input_chanel_attribute_1_0_0_1_0_0_0
  id: iio_input_chanel_attribute
  parameters:
    attribute: '"rf_bandwidth"'
    channel_name: '"voltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(rf_bandwidth)
  states: {}
- name: iio_output_chanel_attribute_0
  id: iio_output_chanel_attribute
  parameters:
    attribute: '"frequency"'
    channel_name: '"altvoltage0"'
    device_name: '"ad9361-phy"'
    uri: uri
    value: str(lo_freq)
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    label: LO Frequency
    type: eng_float
    value: '2400000000'
  states: {}
- name: manual_gain
  id: parameter
  parameters:
    label: Manual Gain (RX1)(dB)
    type: eng_float
    value: '64'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: rf_bandwidth
  id: parameter
  parameters:
    label: RF Bandwidth (Hz)
    type: intx
    value: '20000000'
  states: {}
- name: rf_dc_correction
  id: parameter
  parameters:
    label: RF DC Correction
    type: intx
    value: '1'
  states: {}
- name: sampling_frequency
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2.084e6
  states: {}
- name: uri
  id: parameter
  parameters:
    label: IIO context uri
    type: str
    value: ''
  states: {}

connections:
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_var_to_msg_1, msgout, epy_block_0, inpair]
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
