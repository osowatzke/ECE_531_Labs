options:
  parameters:
    generate_options: qt_gui
    id: PlutoTestSine_38
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: gain_control_mode
  id: variable
  parameters:
    value: '"manual"'
  states: {}
- name: lo_freq
  id: variable
  parameters:
    value: '1000000000'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '71'
    value: '20'
  states: {}
- name: rx_gain_2
  id: variable
  parameters:
    value: rx_gain
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2084000'
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    label: Tone Frequency (Hz)
    start: '1'
    step: '1000'
    stop: '100000'
    value: '10000'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15-1
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15-1
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: (2**15-1)
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: (2**15-1)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr, iio


      class blk(iio.attr_updater):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, **kwargs):  # only default arguments here
              super().__init__(kwargs)
              gr.__init__(self,
                  name="attr_updater",
                  in_sig=None,
                  out_sig=None)

          def set_value(self, **kwargs):
              self.set_params(kwargs)
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, attribute="", value="", interval_ms=1000):  # only default arguments here
              self.iio_attr_updater_1_2 = iio.attr_updater(attribute, str(rx_gain_2), 0)
              
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(self,
                  name="attr_updater",
                  in_sig=None,
                  out_sig=None)
                  
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'True'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'True'
    uri: uri
  states: {}
- name: iio_attr_sink_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_sink_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"altvoltage0"'
    device: '"ad9361-phy"'
    output: 'True'
    uri: uri
  states: {}
- name: iio_attr_sink_0_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"altvoltage1"'
    device: '"ad9361-phy"'
    output: 'True'
    uri: uri
  states: {}
- name: iio_attr_sink_0_2
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'False'
    uri: uri
  states: {}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    attribute: sampling_frequency
    channel: ad9361-phy
    output: 'False'
    samples_per_update: '1024'
    type: '2'
    update_interval_ms: '1'
    uri: 'local:'
  states: {state: disabled}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    interval: '1000'
  states: {state: disabled}
- name: iio_attr_updater_1
  id: iio_attr_updater
  parameters:
    attr: '"sampling_frequency"'
    interval: '0'
    value: str(samp_rate)
  states: {}
- name: iio_attr_updater_1_0
  id: iio_attr_updater
  parameters:
    attr: '"rf_bandwidth"'
    interval: '0'
    value: str(rf_bandwidth)
  states: {}
- name: iio_attr_updater_1_0_0
  id: iio_attr_updater
  parameters:
    attr: '"gain_control_mode"'
    interval: '0'
    value: gain_control_mode
  states: {}
- name: iio_attr_updater_1_1
  id: iio_attr_updater
  parameters:
    attr: '"frequency"'
    interval: '0'
    value: str(lo_freq)
  states: {}
- name: iio_attr_updater_1_1_0
  id: iio_attr_updater
  parameters:
    attr: '"frequency"'
    interval: '0'
    value: str(lo_freq)
  states: {}
- name: iio_attr_updater_1_2
  id: iio_attr_updater
  parameters:
    attr: '"hardwaregain"'
    interval: '0'
    value: str(rx_gain_2)
  states: {}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '32768'
    channels: '["voltage0","voltage1"]'
    cyclic: 'False'
    device: '"cf-ad9361-dds-core-lpc"'
    device_phy: '"ad9361-phy"'
    interpolation: '1'
    params: '[]'
    uri: uri
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '["voltage0","voltage1"]'
    decimation: '1'
    device: '"cf-ad9361-lpc"'
    device_phy: '"ad9361-phy"'
    params: '[]'
    uri: uri
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: variable_qtgui_range_1
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    section: main_after_init
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    section: main_after_init
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_float_1, '0']
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [blocks_complex_to_float_1, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_float_1, '1', blocks_float_to_short_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_1, '0']
- [blocks_float_to_short_0, '0', iio_device_sink_0, '0']
- [blocks_float_to_short_0_0, '0', iio_device_sink_0, '1']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [iio_attr_updater_1, out, iio_attr_sink_0, attr]
- [iio_attr_updater_1_0, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_1_0_0, out, iio_attr_sink_0_0_0, attr]
- [iio_attr_updater_1_1, out, iio_attr_sink_0_1, attr]
- [iio_attr_updater_1_1_0, out, iio_attr_sink_0_1_0, attr]
- [iio_attr_updater_1_2, out, iio_attr_sink_0_2, attr]
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
