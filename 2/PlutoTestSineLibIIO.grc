options:
  parameters:
    generate_options: qt_gui
    id: PlutoTestSine_38
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: lo_freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '71'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.084e6
  states: {}
- name: tone_freq
  id: variable_qtgui_range
  parameters:
    label: Tone Frequency (Hz)
    start: '0'
    step: '1000'
    stop: '100000'
    value: '10000'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: pluto_iio_device_sink_0
  id: pluto_iio_device_sink
  parameters:
    auto_filter: '"True"'
    buffer_size: '32768'
    cyclic: '"True"'
    filter_path: '""'
    lo_freq: lo_freq
    rf_bandwidth: '20000000'
    sample_rate: samp_rate
    tx_atten: '10'
    uri: uri
  states: {}
- name: pluto_iio_device_source_0
  id: pluto_iio_device_source
  parameters:
    auto_filter: '"True"'
    bb_dc_correction: '"True"'
    buffer_size: '32768'
    filter_path: '""'
    gain_control_mode: manual
    lo_freq: lo_freq
    manual_gain: rx_gain
    rf_bandwidth: '20000000'
    rf_dc_correction: '"True"'
    sample_rate: samp_rate
    uri: uri
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', pluto_iio_device_sink_0, '0']
- [pluto_iio_device_source_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
